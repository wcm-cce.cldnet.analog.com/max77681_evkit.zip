# Allegro board MAX77681_EVKIT_REVA_PCB_2017-09-14.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UNNAMED_4_LED_I189_B: length 2.6
  TOP w0.381: D103.K 35.69,81.25 35.68,81.25 v1(35.01,81.25)
  BOTTOM w0.381: R161.1 v1(35.01,81.25)
UNNAMED_4_MAX8512_I5_FB: length 2.4
  BOTTOM w0.381: R160.2 R1.1 8.78,89.14 U103.4
UNNAMED_6_24AA02_I452_SCL: length 2.5
  BOTTOM w0.381: R162.2 51.47,79.33 51.43,79.3 U108.1
UNNAMED_6_24AA02_I452_SDA: length 2.4
  BOTTOM w0.381: R164.1 52.13,77.39 52.11,77.4 U108.3
UNNAMED_6_24AA02_I452_VCC: length 2.9
  BOTTOM w0.381: U108.4 47.44,77.37 C14.2 45.52,77.37 45.49,77.4 R163.1
UNNAMED_6_24AA02_I452_WP: length 2
  BOTTOM w0.254: U108.5 47.25,79.3 46.47,80.08 R165.1
UNNAMED_6_CAPNP_I21_1: length 29.5
  INTERNAL3 w0.254: v1(58.67,51.97) 58.67,48.66 58.49,48.48 v1(58.49,47.78) ; v1(69.82,52.53) 69.82,52.22 69.87,52.17 v1(69.87,44.63)
  BOTTOM w0.254: C203.1 69.87,45.75 v1(69.87,44.63) ; C203.1 69.86,45.78 69.62,46.02 69.42,46.02 69.16,46.27 69.16,46.56 68.81,46.91 U200.7 ; C203.1 69.83,45.79 69.83,45.89 70.7,45.89 R205.1 ; v1(58.49,47.78) 58.92,47.78 R202.2 ; v1(58.67,51.97) 65.25,51.97 65.81,52.53 v1(69.82,52.53)
UNNAMED_6_CAPNP_I271_2: length 16
  BOTTOM w0.127: R229.1 77.16,42.82 73.2,38.86 69.69,38.86 68.47,37.64 U201.5
  BOTTOM w0.152: 70.43,38.86 70.41,38.88 R295.1
  BOTTOM w0.254: U201.5 67.36,38.24 67.37,38.25 C208.2 67.37,40.27 R226.2
UNNAMED_6_CAPNP_I277_1: length 22.8
  INTERNAL3 w0.254: v1(58.42,37.21) 58.42,34.65 v1(57.1,33.32) ; v1(69.34,33.35) v1(69.34,34.85)
  BOTTOM w0.254: v1(69.34,34.85) R228.1 ; R228.1 69.35,35.64 C209.1 ; R228.1 69.25,35.62 68.54,36.34 U201.7 ; R223.2 58.95,37.21 v1(58.42,37.21) ; v1(69.34,33.35) 61.57,33.35 61.54,33.32 v1(57.1,33.32)
UNNAMED_6_CAPNP_I277_2: length 15.2
  BOTTOM w0.127: 68.55,37 68.55,37.33 69.75,38.52 73.39,38.52 76.89,42.03 R230.1
  BOTTOM w0.152: 70.41,38.52 70.43,38.5 R296.2
  BOTTOM w0.254: 68.54,36.99 69.2,36.99 R228.2 70.34,36.84 C209.2 ; 68.54,36.99 U201.6 ; 68.54,36.99 68.55,37
UNNAMED_6_CAPNP_I289_2: length 3.2
  BOTTOM w0.254: R224.2 60.11,37.91 60.42,37.6 60.42,37.57 60.75,37.24 C248.2 60.84,37.16 61.02,36.99 U201.3
UNNAMED_6_CAPNP_I307_2: length 15.9
  BOTTOM w0.127: R242.1 78.01,35.33 77.58,34.9 77.23,34.9 73.14,30.81 70.21,30.81 68.96,29.56 67.99,29.56
  BOTTOM w0.152: 70.56,30.81 70.57,30.82 R297.1
  BOTTOM w0.254: 67.99,29.56 U202.5 67.42,30.17 67.39,30.2 C214.2 67.4,30.89 R240.2
UNNAMED_6_CAPNP_I311_1: length 24.1
  INTERNAL3 w0.254: v1(70.26,24.71) v1(70.26,26.92) ; v1(58.93,29.71) v1(58.93,24.71)
  BOTTOM w0.254: C213.1 70.26,27.57 v1(70.26,26.92) ; C213.1 69.42,27.74 69.34,27.74 68.81,28.26 U202.7 ; C213.1 71.16,27.74 R239.1 ; v1(58.93,24.71) v1(70.26,24.71) ; v1(58.93,29.71) 58.89,29.67 R236.2
UNNAMED_6_CAPNP_I311_2: length 15.9
  BOTTOM w0.127: 68.79,28.91 70.31,30.43 73.27,30.43 77.34,34.5 R243.1
  BOTTOM w0.152: R298.2 70.55,30.42 70.56,30.43
  BOTTOM w0.254: 70.12,28.91 70.13,28.91 70.17,28.94 R239.2 ; 70.12,28.91 70.12,28.92 C213.2 ; 70.12,28.91 U202.6
UNNAMED_6_CAPNP_I323_2: length 3.3
  BOTTOM w0.254: U202.3 61.81,28.91 61.56,29.16 C250.2 60.81,29.16 60.55,29.41 60.55,29.41 60.47,29.49 60.47,29.49 60.27,29.69 59.85,29.69 R237.2
UNNAMED_6_CAPNP_I359_2: length 3.2
  BOTTOM w0.254: R203.2 60.23,48.45 60.75,47.93 C200.2 61.21,47.56 U200.3
UNNAMED_6_EKCAPNP_I10_1: length 3.8
  BOTTOM w0.254: U200.2 60.92,46.91 60.81,46.8 59.89,46.8 C201.1 59.88,47.72 R202.1
UNNAMED_6_EKCAPNP_I10_2: length 1.2
  BOTTOM w0.254: R201.1 58.98,45.68 C201.2
UNNAMED_6_EKCAPNP_I203_2: length 2
  BOTTOM w0.254: U205.1 65.77,73.55 65.83,73.48 C223.2
UNNAMED_6_EKCAPNP_I237_2: length 1.1
  TOP w0.381: C239.2 86.43,48.67 v1(86.54,48.56)
  BOTTOM w0.381: v1(86.54,48.56) 87,48.56 Q200.8
UNNAMED_6_EKCAPNP_I261_2: length 1.3
  TOP w0.254: C240.2 v1(86.71,40.93)
  BOTTOM w0.381: Q201.8 87.25,40.93 v1(86.71,40.93)
UNNAMED_6_EKCAPNP_I287_1: length 4
  BOTTOM w0.254: U201.2 61.09,36.34 60.83,36.08 59.9,36.08 C206.1 59.9,37.16 R223.1
UNNAMED_6_EKCAPNP_I287_2: length 1.2
  BOTTOM w0.254: R222.1 59.01,36.07 C206.2
UNNAMED_6_EKCAPNP_I298_2: length 1.3
  TOP w0.381: C241.2 86.61,33.56 v1(86.66,33.5)
  BOTTOM w0.254: v1(86.66,33.5) 87.14,33.5
  BOTTOM w0.381: 87.14,33.5 Q202.8
UNNAMED_6_EKCAPNP_I321_1: length 4.1
  BOTTOM w0.254: U202.2 60.67,28.26 60.37,27.97 C211.1 59.79,29 R236.1
UNNAMED_6_EKCAPNP_I321_2: length 1.1
  BOTTOM w0.254: C211.2 58.89,26.9 R235.1
UNNAMED_6_EKRESSMD_I42_1: length 15.5
  BOTTOM w0.127: 70.03,48.68 70.02,48.68 R293.1 ; 70.03,48.68 68.98,48.68 68.52,48.21 U200.5 ; 70.03,48.68 76.06,48.68 77.31,49.93 R207.1
  BOTTOM w0.254: 67.44,50.85 67.46,50.84 67.46,49.1 67.4,49.05 U200.5 ; 67.44,50.85 R206.2 ; 67.44,50.85 C204.2
UNNAMED_6_EKRESSMD_I42_2: length 12
  BOTTOM w0.127: R207.2 79.25,49.93 79.78,49.4 82.92,49.4 84.47,50.95 85.27,50.95 85.35,51.03 R211.1
  BOTTOM w0.889: VIL_SBB0.1 81.95,50.7 82.84,51.59 R211.1
UNNAMED_6_EKRESSMD_I43_1: length 14.4
  BOTTOM w0.127: R208.1 77,49.14 76.23,48.36 69.98,48.36 ; 69.98,48.36 69.98,48.36 R294.2 ; 69.98,48.36 69.06,48.36 68.63,47.93 68.63,47.59 68.66,47.56
  BOTTOM w0.254: R205.2 70.7,47.11 69.99,47.11 C203.2 69.5,46.98 68.94,47.55 68.67,47.55 68.66,47.56 U200.6
UNNAMED_6_EKRESSMD_I99_1: length 4.2
  BOTTOM w0.254: 60.81,45.58 60.72,45.67 R201.2 ; 60.81,45.58 60.9,45.58 61.23,45.91 61.23,45.99 61.49,46.26 U200.1 ; 60.81,45.58 60.69,45.46 R204.1
UNNAMED_6_EKRESSMD_I99_2: length 46.8
  INTERNAL3 w0.254: v1(59.17,44.6) 59.17,45.21 59.21,45.24 v1(59.21,55.68)
  BOTTOM w0.254: R204.2 v1(59.17,44.6) ; v1(59.21,55.68) 75.82,55.68 75.98,55.83 88.56,55.83 89.88,54.52 92.45,54.52 92.46,54.51 J200.1
UNNAMED_6_EKRESSMD_I207_1: length 1.6
  BOTTOM w0.254: U205.14 65.77,82.56 R214.1
UNNAMED_6_EKRESSMD_I222_2: length 1.6
  BOTTOM w0.254: U205.12 64.48,80.96 R283.2
UNNAMED_6_EKRESSMD_I273_2: length 11.7
  BOTTOM w0.127: R233.1 85.34,42.76 85.25,42.68 84.49,42.68 83.36,41.55 80.35,41.55 79.08,42.83 78.76,42.83 R229.2
  BOTTOM w0.889: VIL_SBB1.1 83.52,42.81 84.04,43.33 R233.1
UNNAMED_6_EKRESSMD_I278_1: length 4.4
  BOTTOM w0.254: U201.1 62.66,35.08 62.44,34.86 60.83,34.86 60.79,34.91 R222.2 59.89,34.89 R225.1
UNNAMED_6_EKRESSMD_I278_2: length 69.1
  INTERNAL3 w0.254: v1(55.02,34.01) 55.02,33.4 54.89,33.27 v1(54.89,24.06) ; v1(92.1,24.06) 92.56,24.52 92.56,39.88 92.7,40.02 92.7,40.14 J202.1
  BOTTOM w0.254: R225.2 v1(55.02,34.01) ; v1(92.1,24.06) v1(54.89,24.06)
UNNAMED_6_EKRESSMD_I306_2: length 12.1
  BOTTOM w0.127: R242.2 79.43,35.38 80.47,34.34 83.55,34.34 84.95,35.74 84.96,35.74 84.97,35.75 85.51,35.75 85.6,35.84 85.6,36.38 R245.1
  BOTTOM w0.889: VIL_SBB2.1 83.27,36.41 R245.1
UNNAMED_6_EKRESSMD_I313_1: length 4.1
  BOTTOM w0.254: R238.1 59.78,26.77 R235.2 60.55,26.84 61.32,27.61 U202.1
UNNAMED_6_EKRESSMD_I313_2: length 39.2
  BOTTOM w0.254: J204.1 93.94,28.19 93.98,28.14 93.98,26.13 93.19,25.33 59.19,25.33 58.88,25.65 R238.2
UNNAMED_6_EKRESSMD_I450_2: length 1.5
  BOTTOM w0.203: U205.10 63.17,82.35 R305.2
UNNAMED_6_EKRESSMD_I451_2: length 2.7
  BOTTOM w0.203: U205.11 63.82,82.51 63.08,83.25 R306.2
UNNAMED_6_HEADER2P_I444_2: length 5.3
  BOTTOM w0.254: Q201.4 89.81,43.97 90.24,44.4 90.53,44.4 90.53,44.39 R231.2 92.19,44.39 92.73,43.85 93.99,43.85 93.96,43.82 J202.2
UNNAMED_6_HEADER2P_I446_2: length 9.6
  INTERNAL3 w0.254: 93.98,31.87 93.94,31.91 J204.2
  INTERNAL3 w0.381: 93.98,31.87 93.98,35.93 93.92,35.98 v1(93.92,36.66)
  BOTTOM w0.508: v1(93.92,36.66) R244.2 92.14,36.66 92.03,36.76 Q202.4
UNNAMED_6_MAX5815_I205_OUTD: length 2.3
  BOTTOM w0.254: TP1.1 61.98,73.61 62.31,73.61 62.52,73.83 U205.6
UNNAMED_6_RESSMD_I28_2: length 5.4
  BOTTOM w0.254: J200.2 94.05,51.97 94.06,51.98 91.59,51.98 91.52,51.9 R210.2 90.08,51.9 89.97,51.8 Q200.4
VIO: length 159.8
  TOP w0.254: v1(30.47,87.72) v1(32.78,87.72) v1(34.79,87.72) ; v1(10.08,47.04) 20.68,47.04 23.3,44.42 R17.2 ; v1(10.08,41.94) 9.74,42.28 J2.1 ; v1(10.06,27.92) 10.03,27.95 R10.1
  TOP w0.381: v1(38.18,83.92) 20.17,83.92 18.95,82.7 v1(17.14,82.7) ; v1(34.79,87.72) 35.46,87.72 35.5,87.76 v1(38.18,87.76) ; v1(17.88,47.07) 18.08,47.07 18.11,47.04
  TOP w0.508: v1(38.18,87.76) v1(43.76,87.76)
  INTERNAL3 w0.152: 10.06,27.91 v1(10.06,27.92)
  INTERNAL3 w0.254: v1(10.06,27.92) v1(10.06,14.48) ; 10.06,27.91 10.06,41.66 10.08,41.68 v1(10.08,41.94) v1(10.08,47.04)
  INTERNAL3 w0.381: v1(17.88,47.07) 17.88,56.74 17.14,57.48 v1(17.14,82.7) ; v1(38.18,87.76) v1(38.18,83.92)
  INTERNAL3 w0.508: J101.2 43.79,92.67 43.76,92.65 v1(43.76,87.76)
  BOTTOM w0.254: C120.2 29.08,86.28 29.86,85.5 U107.12 30.23,86.88 30.47,87.11 v1(30.47,87.72) 30.47,88.34 R108.1 ; R14.2 34.79,88.35 v1(34.79,87.72) ; R107.1 33.04,87.98 v1(32.78,87.72)
  BOTTOM w0.381: v1(38.18,83.92) 37.28,83.92 37.27,83.91 R143.1
  BOTTOM w0.508: v1(10.06,14.48) 22.68,14.48 22.7,14.45 J4.1
VSYS: length 92.5
  TOP w0.152: 47.15,40.34 47.29,40.48 U1.E4 ; U1.E3 46.89,40.34 ; U1.E2 46.49,40.34
  TOP w0.254: 47.15,40.17 47.15,40.34 ; R2.2 v1(7.12,58.13)
  TOP w0.508: v1(7.12,58.13) 6.26,58.13 2.97,61.42 2.97,63.39 2.32,64.04 SW2.1 ; C30.1 v1(43.34,18.12)
  INTERNAL3 w0.508: v1(7.1,19.94) 7.1,57.38 7.12,57.4 v1(7.12,58.13)
  BOTTOM w0.508: v1(7.1,19.94) 8.76,19.94 10.87,17.83 38.27,17.83 VSYS.1
  vias: v1(41.07,18.08) v1(41.1,17.14) v1(42.27,18.11) v1(42.27,17.17) v1(43.33,17.14) v1(43.33,15.72) v1(43.33,14.1) v1(43.28,13.03) v1(44.35,13) v1(44.4,17.12) v1(44.4,15.7) v1(44.4,14.07) v1(45.47,39.85) v1(45.47,39.19) v1(46.08,39.85) v1(46.08,39.17)
VUSB: length 168.8
  TOP w0.381: v1(48.55,70.54) v1(66.73,70.54) ; v1(10.14,84.41) v1(18.59,84.41) 20.38,86.21 45.8,86.21 v1(46.53,85.47)
  INTERNAL3 w0.381: v1(66.73,70.54) 66.73,44.71 66.84,44.6 v1(66.85,44.6) ; v1(48.55,70.54) v1(48.55,82.58) v1(48.55,94.01) ; v1(10.14,77.91) v1(10.14,84.41)
  INTERNAL3 w0.508: 66.84,44.6 v1(66.84,34.57) v1(66.84,26.44)
  BOTTOM w0.254: v1(66.84,34.57) C207.1 67.36,34.58 U201.8 ; FB100.2 9.88,76.86 10.3,76.44 C108.2 15.84,76.14 U101.19 ; C202.1 67.4,45.23 U200.8 ; U202.8 67.4,27.61 67.4,26.48 C212.1 v1(66.84,26.44)
  BOTTOM w0.381: U102.3 47.24,85.49 ; 47.24,85.49 47.51,85.76 48.38,85.76 48.65,85.49 48.65,84.7 U102.1 48.54,83.26 C118.2 v1(48.55,82.58) ; 47.24,85.49 47.24,85.58 46.83,85.58 46.72,85.47 v1(46.53,85.47) ; R115.1 v1(10.14,77.91) ; R115.1 C154.2 ; R115.1 9.02,77.88 FB100.2 ; C202.1 66.85,44.66 v1(66.85,44.6) ; J100.1 51.56,94.03 51.53,94.01 v1(48.55,94.01) ; U103.3 8.82,87.53 9.14,87.86 9.74,87.86 10.12,87.48 U103.1 10.13,86.68 C110.2 10.14,85.25 v1(10.14,84.41) ; U104.3 16.49,86.39 16.84,86.74 17.59,86.74 17.86,86.47 17.86,85.6 U104.1 17.75,85.49 C112.2 18.03,84.41 v1(18.59,84.41)

## Copper pours and planes (outline as drawn)
GROUND on TOP: 0.99,95.55 0.99,11.02 95.94,11.02 95.94,95.55 ; 6 cut-outs
GROUND on BOTTOM: 1.4,94.87 1.55,10.74 95.66,10.87 95.63,96.01 3.56,96.01 ; 22 cut-outs
GROUND on INTERNAL2: 1.3,95.28 1.3,11.23 95.4,11.23 95.4,95.28 ; 1 cut-out
LXA on TOP: 46,36.07 46,38.48 47.27,38.48 47.27,36.07
LXB on TOP: 47.88,36.07 47.88,38.48 49.15,38.48 49.15,36.07
SBB0 on TOP: 48.39,41.43 48.39,41.55 48.64,41.8 48.64,44.22 52.07,47.65 86.66,47.65 86.66,45.01 59.33,45.01 58.67,44.98 54.23,44.98 52.45,43.21 50.55,43.21 48.77,41.43
SBB1 on TOP: 52.96,40.67 53.34,40.28 54.99,40.28 57.53,37.74 86.66,37.69 86.66,39.93 86.46,40.13 58.55,40.16 56.77,41.94 51.18,41.94 50.67,41.43 50.67,40.92 50.93,40.67
SBB2 on TOP: 50.8,39.78 60.96,29.62 86.56,29.57 86.77,29.77 86.77,32.61 61.26,32.61 53.98,40.03 53.09,40.03 52.7,40.41 50.8,40.41
UNNAMED_6_EKCAPNP_I237_2 on BOTTOM: 87,45.09 91.77,45.06 91.77,50.85 87,50.88
UNNAMED_6_EKCAPNP_I261_2 on BOTTOM: 87.09,41.27 87.09,37.8 91.8,37.77 91.8,41.27 90.55,42.49 90.53,43.08 87.1,43.08
UNNAMED_6_EKCAPNP_I298_2 on BOTTOM: 87.12,35.92 87.11,30.45 91.69,30.45 91.72,35.92
UNNAMED_6_EKRESSMD_I42_2 on BOTTOM: 88.65,51.44 86.61,51.44 86.31,51.13 84.84,51.13 84.84,52.2 85.34,52.7 88.65,52.7
UNNAMED_6_EKRESSMD_I273_2 on BOTTOM: 88.65,44.45 88.65,43.56 86.74,43.56 86.08,42.89 84.96,42.89 84.96,44.07 85.34,44.45
UNNAMED_6_EKRESSMD_I306_2 on BOTTOM: 88.77,36.32 86.87,36.32 86.5,35.96 85.21,35.95 85.22,37.21 88.77,37.21
VSYS on TOP: 46.35,40.51 47.24,40.51 47.24,38.86 45.21,38.86 45.21,40.11 45.95,40.11
VSYS on TOP: 39.62,18.97 39.62,12.75 44.63,12.75 44.63,18.97
VSYS on INTERNAL3: 35.56,60.96 35.56,12.7 60.96,12.7 60.96,60.96 ; 1 cut-out

Small or netless copper shapes (teardrops, artwork): 2 on TOP, 2 on INTERNAL2

## Text on the board
Ref Des/Silkscreen Top: EN_EXT | SCL | SDA | GND | nIRQ | nRST | VIO | nEN | PWRHLD | SW2 | GPIO | SW1 | RX | TX | INTERRUPT | PENDING | 3.3V_OK | 3.3V | 1.8V | VUSB | +3.3V | SCL1 | SDA1 | ENEXT | www.maximintegrated.com | 1-408-601-1000 | LB 09/17 | MAX77681 EVKIT REVA
FAB_NOTES: NOTES: | FINISH: | TESTING: | MISCELLANEOUS: | TOOLING: | 15.  CHECK ALL THAT APPLY | 16.  VENDOR LOGO & DATE CODE REQUIRED IN INK ON BOTTOM SIDE ONLY. DATE CODE FORMAT MUST BE YYWW ONLY | 17.  FINAL ELECTRICAL TEST TO BE PERFORMED USING PROVIDED IPC-D-356A NETLIST OR ODB++ FORMAT FILE. | 18.  A TIME DOMAIN REFLECTOMETER REPORT FOR EACH IMPEDANCE CONTROLLED LAYER AND A CERTIFICATE | 24.  THIEVING: | 23.  FINISHED SURFACE CONTACTS AND FILLED VIAS TO BE FREE OF ANY PITS. SCRATCHES PROBE MARKS | 19.  FOR BLIND AND BURIED VIA INFORMATION REFER TO DRILL CHART. | 21.  ALL MICRO-VIAS LESS THAN 0.006 INCHES FHS WILL BE PLATED SHUT WITH COPPER, UNLESS OTHERWISE SPECIFIED. | 22.  FOR VIA SIZES XX.XX INCH USE NON CONDUCTIVE VIA FILL AND CAP | 13.  DRILL SIZES ARE FINISHED HOLE SIZES. ALL HOLES SHALL BE LOCATED WITHIN .005 DTP. | 14.  CHECK ALL THAT APPLY | 25.  PEMNUT | 9.  ALL TRACES FILLETED OPTION TO ENHANCE RELIABILITY AT PAD JUNCTIONS | 10.  LAYER TO LAYER REGISTRATIONS SHALL BE WITHIN .003 INCHES. | MATERIAL: | 11.  FINISHED COPPER WEIGHT/THICKNESS: | 12.  CHECK ALL THAT APPLY | 8.  IF STATED IN THE LAMINATION DIAGRAM, THE DIELECTRIC THICKNESS OF ANY | 1.  DIMENSIONS ARE IN INCHES (EXCEPT WHERE NOTED). | 3.  THE PCB SHALL BE FABRICATED TO IPC-6012, TYPE X, CLASS 2. | 4.  BOARD MATERIAL & CONSTRUCTION SHALL MEET THE REQUIREMENTS OF UL796 | 5.  OVERALL BOARD THICKNESS REFER TO LAMINATION DIAGRAM. TOLERANCE APPLIES | 6.  BOW & TWIST NOT TO EXCEED 0.0075 IN. (0.75%) PER LINEAR INCH. | 7.  PHOTO ETCH CIRCUITRY PER ENCLOSED GERBER RS274X OR ODB++ FORMAT FILE. | 2.  BOARD MATERIAL: | ( )  APPLY SILKSCREEN TO TOP SIDE USING A NON-CONDUCTIVE, WHITE EPOXY | ( )  OTHER ________________________ | (x)  APPLY SILKSCREEN TO BOTH SIDES USING A NON-CONDUCTIVE, WHITE EPOXY | (x)  GREEN SOLDERMASK OVER BARE COPPER/BARE GOLD (BOTH SIDES) WITH LIQUID PHOTO IMAGEABLE INK (LPI) | ( )  GREEN TAIYO PSR-4000 | (X)  REFER TO LAMINATION DIAGRAM FOR FINISHED COPPER WEIGHT/THICKNESS REQUIREMENTS. | ( )  FINGERS TO BE GOLD PLATED. | ( )  FINISH CONDUCTOR SURFACES: IMMERSION GOLD, 2-5 MICRO INCHES OVER | (X)  SUPPLIER MAY ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS ON THIS DESIGN. | ( )  SUPPLIER MAY NOT ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS ON THIS DESIGN. | ( )  NON-CONDUCTIVE EPOXY. FILL AND CAP ALL 0.XXXX INCH DRILLED VIAS. | ( )  SILVER. FILL AND CAP ALL 0.XXXX INCH DRILLED VIAS. | ( )  ELECTODEPOSITED HARD GOLD PLATE, TYPE 1 (99.7% MIN GOLD), GRADE C | (X) LEAD FREE AND RoHS COMPLIANT OR EQUIVALENT LEAD FREE PLATING | (REQUIRED UNLESS OTHERWISE SPECIFIED IN QUOTE) | THE PCB SHALL HAVE A VERIFICATION STAMP. | OF COMPLIANCE SHALL BE PROVIDED BY VENDOR AT TIME OF SHIPMENT. | ( )  PEMNUT TO BE INSTALLED BY SUPPLIER | ( )  PEMNUT NOT TO BE INSTALLED BY SUPPLIER | OR OTHER DEFORMITIES THAT COULD EFFECT THE APPERANCE AND PERFORMACE OF THE CONTACT | SURFACE. CONTACTS ARE TO BE AS FLAT AS POSSIBLE. NOT TO EXCEED +/- 0.001" OF FLATNESS. | (x)  FINISH CONDUCTOR SURFACES: IMMERSION GOLD, 3-8 MICRO INCHES OVER | ( )  FILLETED | (X)  NOT FILLETED | SO AS TO HINDER PROPER SOLDER WICKING. | (X)  ISOLA 370HR OR EQUIVALENT | ( )  NELCO-4000-13 | ( )  MEGTRON 6 | ( )  ROGERS 4350B | ( )  ROGERS 4003C | MINIMUM BARREL PLATING OF .001 IN. PLATED HOLES SHALL NOT BE ROUGH OR IRREGULAR | ( )  ISOLA-FR408HR OR EQUIVALENT | CONTROLLED IMPEDANCE LAYER IS FOR REFERENCE ONLY. FINAL ACCEPTANCE | SHALL BE DETERMINED BY THESE LAYERS HAVING A CHARACTERISTIC | IMPEDANCE OF +/-10% OHMS AS STATED IN THE LAMINATION DIAGRAM. THE | VENDOR CAN MAKE ADJUSTMENTS AS LONG AS THE STATED IMPEDANCE AND | OVERALL BOARD THICKNESS IS MAINTAINED. ANY ADJUSTMENT MADE TO TRACE | WIDTH OR SPACING MUST HAVE PRIOR WRITTEN APPROVAL FROM MAXIM. | WHERE SPACING PERMITS. | LEGEND TO LEGEND +/- 0.007 INCHES | WORKMANSHIP SHALL CONFORM TO IPC-A-600, CLASS 2, CURRENT REVISIONS. | WITH FLAMMABILITY RATING OF 94V-O. | AFTER ALL LAMINATION AND PLATING PROCESSES. IT IS TO BE MEASURED FROM | TOP PCB METAL TO BOTTOM PCB METAL UNLESS OTHERWISE SPECIFIED. | BOW & TWIST SHOULD BE MEASURED PER IPC-TM-650, METHOD 2.4.22. | DRILL LOCATION AND SIZE CONTROLLED BY EXCELLON CNC DRILL FILE. | UNLESS OTHERWISE SPECIFIED | BASED INK PER ARTWORK. | PER ARTWORK. | THE STARTING COPPER WEIGHT/THICKNESS CAN VARY AS LONG AS THE FINISHED COPPER | WEIGHT/THICKNESS IS NOT LESS THAN THE SPECIFIED VALUE. UNLESS OTHERWISE SPECIFIED. | (KNOOP HARDNESS 130-200), CLASS 1 (50-100 MICRO INCHES THICK) IN ACCORDANCE WITH MIL-G-45204C. | GENERAL SURFACING REQUIREMENTS MUST MEET ANSI/IPC-A-600(CURRENT REV) SECTION 4.0, | CLASS 3 (50-100 MICROINCHES THICK) OVER ELECTRODEPOSITED NICKEL PLATE | IN ACCORDANCE WITH ANSI/IPC-A-600D, SECTION 4.0, CLASS 3 (200-600 MICROINCHES THICK). | 118-236 MICRO INCHES MINIMUM OF ELECTROLESS NICKEL. | 100 MICRO INCHES MINIMUM OF ELECTROLESS NICKEL. | (USE CHECKED ITEMS FOR MATERIAL) | (USE CHECKED ITEMS FOR PLATING) | (USE CHECKED ITEMS FOR TOOLING) | UNLESS OTHERWISE SPECIFIED: | NOT TO SCALE | TEMPLATE REV 1.7 | TOLERANCES UNLESS OTHERWISE SPECIFIED | +/- | FRACTIONS | SEE NOTES | .XXX +/- .005 | .XX +/- .01 | DECIMALS | ANGLES | THE INFORMATION CONTAINED IN THIS DOCUMENT | IS PROPRIETARY TO MAXIM. THE INFORMATION IN | THIS DOCUMENT IS NOT TO BE SHOWN, REPRODUCED, | OR DISCLOSED TO ANYONE OUTSIDE OF MAXIM | WITHOUT PRIOR WRITTEN PERMISSION FROM MAXIM. | DRAWN BY: | CHECK BY:RYAN MARQUISS | APPR. BY: | LAKSHMI BHUJ | DATE: | DATE:9/14/2017 | 9/14/2017 | SIZE | E | DRAWING NO. | SHEET 1 OF 1 | REV | A | DESCRIPTION | REVISIONS | APPROVED | DATE | TITLE: | RELEASE | MAX77681 EVALUATION BOARD | FABRICATION DWG. | XX-XXXXXX-XX
User.25: FIGURE | SIZE | 4.0 | 8.0 | 12.01 | 39.37 | 45.28 | 62.99 | 70.87 | 125.0 | 35.43 | 41.34x25.59 | 51.18x27.56 | TOLERANCE | +0.0/-4.0 | +3.0/-6.0 | +3.0/-3.0 | PLATED | NON-PLATED | ALL UNITS ARE IN MILS | QTY | 20 | 309 | 9 | 17 | 39 | 4 | 5 | 2 | NOTES | DRILL CHART: TOP to BOTTOM
